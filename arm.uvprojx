# Keil uVision project arm.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: arm +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Mainpulator;.\CMSIS;.\Library\STM32F10x_StdPeriph_Driver\inc;.\Library\mcu_fun\inc;.\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\Hardware\delay;.\Hardware\led;.\Hardware\arm;.\Hardware\usart;.\Hardware\spi;.\APP\debug;.\APP\Nrf24L01;.\APP\Communication
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ./Library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group mcu_fun
    ./Library/mcu_fun/src/: mcu_gpio.c mcu_dma.c mcu_spi.c mcu_timer.c mcu_usart.c mcu_nvic.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Hardware
    ./Hardware/delay/: delay.c
    ./Hardware/led/: led.c
    ./Hardware/arm/: arm.c
    ./Hardware/usart/: usart.c
    ./Hardware/spi/: spi.c
  group APP
    ./APP/debug/: debug.c
    ./APP/Nrf24L01/: nrf24l01.c
    ./APP/Communication/: communication.c
  group FreeRTOS
    ./FreeRTOS/Source/: tasks.c queue.c list.c
    ./FreeRTOS/Source/portable/MemMang/: heap_4.c
    ./FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
